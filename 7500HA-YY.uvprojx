# Keil uVision project 7500HA-YY.uvprojx, settings and files
target hk32f030k6t6a (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HK32F030K6TxA HK_MicroChip
  pack: HKMicroChip.HK32F0xx_DFP.1.1.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: 7500HA-YY +hex
  AfterMake: fromelf.exe --bin -o "./Objects/7500HA-YY.bin" "./Objects/7500HA-YY.axf"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,HK32F030xxA
  c include: .\HK32F0xxA_StdPeriphDriver\inc;.\CMSIS\HK32F0xxA\Include;.\user\inc;.\CMSIS\CM0\Core;.\MyDriver\inc;.\CoeffCountMod
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group user
    ./user/src/: main.c hk32f0xxa_it.c SubFun.c ResultCount.c measurement_core.c
    ./CMSIS/HK32F0xxA/Source/: system_hk32f0xxa.c
  group Lib
    ./HK32F0xxA_StdPeriphDriver/src/: hk32f0xxa_adc.c hk32f0xxa_flash.c hk32f0xxa_gpio.c hk32f0xxa_iwdg.c hk32f0xxa_rcc.c hk32f0xxa_tim.c hk32f0xxa_usart.c hk32f0xxa_misc.c hk32f0xxa_exti.c hk32f0xxa_syscfg.c
  group CMSIS
    ./CMSIS/HK32F0xxA/Source/ARM/: startup_hk32f030xxa.s
  group MyDriver
    ./MyDriver/src/: si70xx.c gpio.c flash.c usart.c tim.c adc.c pwm.c cap.c Linearization.c ntc.c WarnMod.c RXExecute.c protocol_codec.c persistent_codec.c iwdg.c GXHT40.c IIC_GXHT40.c IIC_LQTP.c LQTP.c
    ./CoeffCountMod/: CoeffCountMod V3.0 USF.lib
